# IAR project baremetal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF5340_xxAA_App NordicSemi nRF5340_xxAA_App
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCIncludePath2: inc; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: baremetal.srec
  ILINK.IlinkOutputFile: baremetal.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: iar_startup_nrf5340_application.s main.c
  group inc
    inc/: compiler_abstraction.h nrf.h nrf5340_application.h nrf5340_application_bitfields.h nrf5340_application_name_change.h nrf5340_application_peripherals.h nrf5340_xxaa_application_memory.h nrf_common.h nrf_gpio.h nrf_mem.h nrf_peripherals.h nrf_user_config.h nrfx.h nrfx_common.h nrfx_config.h nrfx_config_common.h nrfx_config_ext.h nrfx_config_nrf5340_application.h nrfx_errors.h nrfx_ext.h nrfx_glue.h nrfx_utils.h nrfx_utils_internal.h nrfy_common.h system_nrf5340_application.h
  group src
    src/: system_nrf5340_application.c
